# Keil uVision project template.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x00000000,0x00080000) IROM(0x10000000,0x00200000) XRAM(0x01000000,0x00100000) XRAM2(0x20000000,0x00020000) XRAM3(0x20020000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x1000000 size 0x100000
  memory RVCT7: RAM 0x20000000 size 0x20000
  memory RVCT8: RAM 0x20020000 size 0x20000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x80000
  scatter file: .\template.sct
  link misc: --entry=__trampoline_entry
  group Application
    ./: main.c
  group trampoline
    ./: trampoline.c trampoline_cfg.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.4.0
